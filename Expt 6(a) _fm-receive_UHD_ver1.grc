<?xml version='1.0' encoding='utf-8'?>
<?grc format='1' created='3.7.13'?>
<flow_graph>
<block>
<key>options</key>
<param><key>id</key><value>top_block</value></param>
<param><key>category</key><value>Custom</value></param>
<param><key>generate_options</key><value>wx_gui</value></param>
<param><key>run_options</key><value>run</value></param>
</block>
<block>
<key>variable_slider</key>
<param><key>id</key><value>fm_station</value></param>
<param><key>converver</key><value>float_converter</value></param>
<param><key>value</key><value>92.7e6</value></param>
<param><key>label</key><value></value></param>
<param><key>max</key><value>105e6</value></param>
<param><key>min</key><value>91e6</value></param>
<param><key>num_steps</key><value>1000</value></param>
<param><key>style</key><value>wx.SL_HORIZONTAL</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>sample_rate</value></param>
<param><key>value</key><value>1536000</value></param>
</block>
<block>
<key>analog_wfm_rcv</key>
<param><key>id</key><value>analog_wfm_rcv_0</value></param>
<param><key>audio_decimation</key><value>8</value></param>
<param><key>quad_rate</key><value>384000</value></param>
</block>
<block>
<key>audio_sink</key>
<param><key>id</key><value>audio_sink_0</value></param>
<param><key>samp_rate</key><value>48000</value></param>
</block>
<block>
<key>low_pass_filter</key>
<param><key>id</key><value>low_pass_filter_0</value></param>
<param><key>cutoff_freq</key><value>96000</value></param>
<param><key>decim</key><value>sample_rate/384000</value></param>
<param><key>type</key><value>fir_filter_ccf</value></param>
<param><key>gain</key><value>1</value></param>
<param><key>samp_rate</key><value>sample_rate</value></param>
<param><key>width</key><value>15000</value></param>
<param><key>win</key><value>firdes.WIN_BLACKMAN</value></param>
</block>
<block>
<key>rtlsdr_source</key>
<param><key>id</key><value>rtlsdr_source_0</value></param>
<param><key>bb_gain0</key><value>20</value></param>
<param><key>bw0</key><value>sample_rate</value></param>
<param><key>freq0</key><value>100.1e6</value></param>
<param><key>gain_mode0</key><value>False</value></param>
<param><key>if_gain0</key><value>20</value></param>
<param><key>iq_balance_mode0</key><value>1</value></param>
<param><key>gain0</key><value>10</value></param>
<param><key>args</key><value>'rtl-0'</value></param>
<param><key>type</key><value>fc32</value></param>
<param><key>sample_rate</key><value>sample_rate</value></param>
<param><key>sync</key><value></value></param>
</block>
<block>
<key>uhd_usrp_source</key>
<param><key>id</key><value>uhd_usrp_source_0</value></param>
<param><key>ant0</key><value>RX2</value></param>
<param><key>bw0</key><value>200e3</value></param>
<param><key>center_freq0</key><value>fm_station</value></param>
<param><key>dc_offs_enb0</key><value>""</value></param>
<param><key>iq_imbal_enb0</key><value>""</value></param>
<param><key>norm_gain0</key><value>False</value></param>
<param><key>gain0</key><value>40</value></param>
<param><key>clock_rate</key><value>0.0</value></param>
<param><key>dev_args</key><value>""</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>clock_source0</key><value>internal</value></param>
<param><key>time_source0</key><value>external</value></param>
<param><key>type</key><value>fc32</value></param>
<param><key>samp_rate</key><value>sample_rate</value></param>
<param><key>hide_cmd_port</key><value>False</value></param>
<param><key>hide_lo_controls</key><value>True</value></param>
<param><key>sync</key><value></value></param>
</block>
<block>
<key>wxgui_fftsink2</key>
<param><key>id</key><value>wxgui_fftsink2_0</value></param>
<param><key>avg_alpha</key><value>0</value></param>
<param><key>average</key><value>False</value></param>
<param><key>baseband_freq</key><value>fm_station</value></param>
<param><key>fft_size</key><value>1024</value></param>
<param><key>freqvar</key><value>None</value></param>
<param><key>peak_hold</key><value>False</value></param>
<param><key>ref_level</key><value>0</value></param>
<param><key>ref_scale</key><value>2.0</value></param>
<param><key>fft_rate</key><value>15</value></param>
<param><key>samp_rate</key><value>sample_rate</value></param>
<param><key>title</key><value>FFT Plot</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>win</key><value>None</value></param>
<param><key>y_divs</key><value>10</value></param>
<param><key>y_per_div</key><value>10</value></param>
</block>
<connection><source_block_id>analog_wfm_rcv_0</source_block_id><sink_block_id>audio_sink_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>low_pass_filter_0</source_block_id><sink_block_id>analog_wfm_rcv_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>rtlsdr_source_0</source_block_id><sink_block_id>low_pass_filter_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>rtlsdr_source_0</source_block_id><sink_block_id>wxgui_fftsink2_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>uhd_usrp_source_0</source_block_id><sink_block_id>low_pass_filter_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>uhd_usrp_source_0</source_block_id><sink_block_id>wxgui_fftsink2_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
</flow_graph>
